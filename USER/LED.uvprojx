# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;.\Firmware_library\Basic;.\Firmware_library\Peripheral;..\USER;.\USMART;.\Firmware_library\Scoke;.\Firmware_library\Database;.\SD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: LED.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Basic
    ./Firmware_library/Basic/: irq.c myiic.c STM32_EXTI.c STM32_gpio.c STM32_TIM.c STM32_usart.c STM32_spi.c STM32_ADC.c
  group Peripheral
    ./Firmware_library/Peripheral/: dht11.c DS1302.c GY.c HC595DAC0832.c him.c lcd1602.c lcd12864.c led_1488.c oled.c QDtech.c NRF24L01.c W5500.c TFT.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
  group scoke
    ./Firmware_library/Scoke/: http_head.c
